# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\TASK\actuator_app_play;..\TASK\Get_Sensors_Data;..\TASK\lcd_app_play;..\TASK\user_app_play;..\TASK\wifi_app_play;..\HARDWARE\RFID;..\HARDWARE;..\HARDWARE\LCD;..\HARDWARE\WIFI\cloud;..\HARDWARE\WIFI;..\TASK\wifi_receive_play;..\cjson
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/: adc.c rc522.c dht11.c spi.c gpio.c TIM3_CAP.c key1.c usart2.c usart4.c tim7.c beep.c sg90.c stmflash.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/WIFI/: HAL_WiFiToCloud.c WiFiToCloud.c hal_uart3.c
    ../cjson/: cJSON.c cJSON_Utils.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_flash.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
  group TASK
    ../TASK/Get_Sensors_Data/: Get_Sensors_DataTask.c
    ../TASK/actuator_app_play/: actuator_app_playTask.c
    ../TASK/lcd_app_play/: lcd_app_playTask.c
    ../TASK/user_app_play/: user_app_playTask.c
    ../TASK/wifi_app_play/: wifi_app_playTask.c
    ../TASK/wifi_receive_play/: wifi_receive_play.c
